# Keil uVision project VirtualCOM.uvprojx, settings and files
target STM32F103 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCOM +hex
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: VirtualCOM.c USBD_User_CDC_ACM_UART_0.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, USB:CORE 6.13.6, USB:Device 6.13.6, USB:Device:CDC 6.13.6, CMSIS Driver:USART 2.3, CMSIS Driver:USB Device 2.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0
